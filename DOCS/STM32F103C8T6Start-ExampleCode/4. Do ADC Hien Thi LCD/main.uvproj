# Keil uVision project main.uvproj, settings and files
target Do ADC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\FWlib\Include;.\Main;.\Device\Include;.\User\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start Up
    ./Startup/CM3/: core_cm3.c system_stm32f10x.c
    ./Startup/: startup_stm32f10x_md.s
    ./FWlib/Source C/: misc.c stm32f10x_dma.c
  group FWLib
    ./FWlib/Source C/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c
  group User
    ./User/Source C/: user_delay.c user_gpio.c user_adc.c user_dma.c user_nvic.c user_interrupt.c
  group Main
    ./Main/: main.c
  group Device
    ./Device/Source C/: lcd16x2.c
